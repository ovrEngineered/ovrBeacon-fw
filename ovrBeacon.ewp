# IAR project ovrBeacon.ewp, settings and files
configuration debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F128.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.CCDefines: BG_DEBUG
  ICC8051.CCDiagSuppress: Pa050,Ta045
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $EW_DIR$\Bluegiga\ble-1.3\include; project\include; config; externals\common-c\include\arch-ble112; externals\common-c\include\arch-common; externals\common-c\include\collections; externals\common-c\include\lang; externals\common-c\include\logger; externals\common-c\include\misc; externals\common-c\include\peripherals; externals\common-c\include\serial; externals\common-c\include\stateMachine; externals\common-c\include\timeUtils
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  prebuild: "$EW_DIR$\Bluegiga\ble-1.3\bin\bgbuild.exe" "config\project.bgproj"
  XLINK.XclFile: $EW_DIR$\Bluegiga\ble-1.3\linker\blestack_debug.xcl
configuration release (8051)
  as the first configuration, except:
  XLINK.XclFile: $EW_DIR$\Bluegiga\ble-1.3\linker\blestack.xcl
configuration bgbuild (8051)
  as the first configuration, except:
  postbuild: "$EW_DIR$\Bluegiga\ble-1.3\bin\fwmem.exe" "bgbuild\list\$TARGET_BNAME$.map" "$TARGET_BPATH$.mem"
  XLINK.XclFile: $EW_DIR$\Bluegiga\ble-1.3\linker\blestack_bgbuild.xcl
  group (top)
    $EW_DIR$/Bluegiga/ble-1.3/lib/: blestack2541.r51
  group Config
    config/: gatt.xml hardware.xml license.xml project.bgproj
  group externals/common-c/include/arch-ble112
    externals/common-c/include/arch-ble112/: cxa_ble112_adcChannel.h cxa_ble112_clockController.h cxa_ble112_dmaController.h cxa_ble112_gpio.h cxa_ble112_timeBase.h cxa_ble112_usart.h
  group externals/common-c/include/arch-ble112/sys
    externals/common-c/include/arch-ble112/sys/: types.h
  group externals/common-c/include/arch-common
    externals/common-c/include/arch-common/: cxa_adcChannel.h cxa_batteryCapacityEstimator.h cxa_delay.h cxa_gpio.h cxa_gpio_debouncer.h cxa_led.h cxa_led_gpio.h cxa_tempSensor.h cxa_tempSensor_adc.h cxa_timeBase.h cxa_usart.h
  group externals/common-c/include/collections
    externals/common-c/include/collections/: cxa_array.h cxa_fixedByteBuffer.h cxa_fixedFifo.h cxa_linkedField.h
  group externals/common-c/include/logger
    externals/common-c/include/logger/: cxa_logger_header.h cxa_logger_implementation.h
  group externals/common-c/include/misc
    externals/common-c/include/misc/: cxa_assert.h cxa_numberUtils.h
    EXTERNALS/common-c/include/misc/: cxa_stringUtils.h
  group externals/common-c/include/peripherals
    externals/common-c/include/peripherals/: cxa_ws2812String.h
  group externals/common-c/include/serial
    externals/common-c/include/serial/: cxa_ioStream.h
  group externals/common-c/include/stateMachine
    externals/common-c/include/stateMachine/: cxa_stateMachine.h
  group externals/common-c/include/timeUtils
    externals/common-c/include/timeUtils/: cxa_timeDiff.h
  group externals/common-c/src/arch-ble112
    EXTERNALS/common-c/src/ARCH-BLE112/: cxa_ble112_adcChannel.c
    externals/common-c/src/arch-ble112/: cxa_ble112_clockController.c cxa_ble112_delay.c cxa_ble112_dmaController.c cxa_ble112_gpio.c cxa_ble112_timeBase.c cxa_ble112_usart.c cxa_ble112_ws2812String.c
  group externals/common-c/src/arch-common
    EXTERNALS/common-c/src/ARCH-COMMON/: cxa_adcChannel.c cxa_batteryCapacityEstimator.c
    externals/common-c/src/arch-common/: cxa_gpio.c cxa_gpio_debouncer.c cxa_led.c cxa_led_gpio.c cxa_tempSensor.c cxa_tempSensor_adc.c cxa_usart.c
  group externals/common-c/src/collections
    externals/common-c/src/collections/: cxa_array.c cxa_fixedByteBuffer.c cxa_fixedFifo.c cxa_linkedField.c
  group externals/common-c/src/logger
    externals/common-c/src/logger/: cxa_logger.c
  group externals/common-c/src/misc
    externals/common-c/src/misc/: cxa_assert.c cxa_numberUtils.c cxa_stringUtils.c
  group externals/common-c/src/peripherals
    EXTERNALS/common-c/src/PERIPHERALS/: cxa_ws2812String.c
  group externals/common-c/src/serial
    externals/common-c/src/serial/: cxa_ioStream.c
  group externals/common-c/src/stateMachine
    externals/common-c/src/stateMachine/: cxa_stateMachine.c
  group externals/common-c/src/timeUtils
    externals/common-c/src/timeUtils/: cxa_timeDiff.c
  group project/include
    project/include/: cxa_config.h ovr_ovrBeaconManager.h
  group project/src
    project/src/: main.c ovr_ovrBeaconManager.c
